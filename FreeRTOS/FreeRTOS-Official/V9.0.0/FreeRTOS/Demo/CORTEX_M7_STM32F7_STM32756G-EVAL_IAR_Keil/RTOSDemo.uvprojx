# Keil uVision project RTOSDemo.uvprojx, settings and files
target STM32756G_EVAL (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F756xx, CORE_CM7,USE_HAL_DRIVER
  c include: .\CMSIS\Device\ST\STM32F7xx\Include;.\CMSIS\Include;.\ST_Library\include;.;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM7\r0p1;..\Common\include;.\Full_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group User
    ./Blinky_Demo/: main_blinky.c
    ./: main.c FreeRTOSConfig.h
    ./Full_Demo/: main_full.c IntQueueTimer.c RegTest_Keil.c
  group ST Library
    ./ST_Library/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim_ex.c
  group System
    ./System_Keil/: system_stm32f7xx.c stm32f7xx_it.c stm32f7xx_hal_msp.c startup_stm32f756xx.s
  group FreeRTOS Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Common Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c integer.c IntQueue.c IntSemTest.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
software components: CMSIS:CORE 4.3.0
